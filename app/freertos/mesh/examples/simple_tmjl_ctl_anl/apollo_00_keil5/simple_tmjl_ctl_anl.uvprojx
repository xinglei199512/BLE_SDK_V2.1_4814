# Keil uVision project simple_tmjl_ctl_anl.uvprojx, settings and files
target BLueX Mesh (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: simple_tmjl_ctl_anl +hex
  AfterMake: ..\..\..\..\..\..\tools\image_tool_v2\disassemble.bat @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --bss_threshold=0
  c include: ..\..\..;..\..\..\adapter;..\..\..\mesh_test;..\..\..\provision;..\..\..\provision\api;..\..\..\model;..\..\..\model\api;..\..\..\model\generics;..\..\..\model\generics\generic_onoff;..\..\..\model\generics\generic_onoff\client;..\..\..\model\generics\generic_onoff\server;..\..\..\model\generics\generic_level;..\..\..\model\generics\generic_level\client;..\..\..\model\generics\generic_level\server;..\..\..\model\generics\generic_transition;..\..\..\model\generics\generic_transition\client;..\..\..\model\generics\generic_transition\server;..\..\..\model\generics\generic_power_onoff;..\..\..\model\generics\generic_power_onoff\client;..\..\..\model\generics\generic_power_onoff\server;..\..\..\model\foundation_models;..\..\..\model\foundation_models\config;..\..\..\model\foundation_models\config\server;..\..\..\model\foundation_models\config\client;..\..\..\model\foundation_models\health;..\..\..\model\foundation_models\health\server;..\..\..\model\foundation_models\health\client;..\..\..\model\custom_models;..\..\..\model\custom_models\tmall;..\..\..\model\custom_models\tmall\client;..\..\..\model\custom_models\tmall\server;..\..\..\model\light_mode;..\..\..\model\light_mode\light_ctl;..\..\..\model\light_mode\light_ctl\client;..\..\..\model\light_mode\light_ctl\server;..\..\..\model\light_mode\light_hsl;..\..\..\model\light_mode\light_hsl\client;..\..\..\model\light_mode\light_hsl\server;..\..\..\model\light_mode\light_lightness;..\..\..\model\light_mode\light_lightness\client;..\..\..\model\light_mode\light_lightness\server;..\..\..\model\time_and_scenes;..\..\..\model\time_and_scenes\time;..\..\..\model\time_and_scenes\time\client;..\..\..\model\time_and_scenes\time\server;..\..\..\model\time_and_scenes\scene;..\..\..\model\time_and_scenes\scene\client;..\..\..\model\time_and_scenes\scene\server;..\..\..\model\time_and_scenes\scheduler;..\..\..\model\time_and_scenes\scheduler\client;..\..\..\model\time_and_scenes\scheduler\server;..\..\..\gatt;..\..\..\gatt\api;..\..\..\gatt\proxy\server;..\..\..\gatt\provisioning\server;..\..\..\core;..\..\..\core\api;..\..\..\core\core_config;..\..\..\uart_ctrl;..\..\..\device_manager;..\..\..\device_manager\api;..\..\..\device_manager\keys;..\..\..\device_manager\node_save;..\..\..\unit_test;..\..\..\..;..\..\..\..\src\include;..\..\..\..\src\portable\ARMCC\arm_cm0;..\..\..\..\utils\bond;..\..\..\..\utils;..\..\..\..\..\..;..;..\..\..\..\..\..\plf\apollo_00\src\arch;..\..\..\..\..\..\plf\apollo_00\src\arch\boot\ARMCC;..\..\..\..\..\..\plf\apollo_00\src\arch\compiler\ARMCC;..\..\..\..\..\..\plf\apollo_00\src\arch\ll;..\..\..\..\..\..\plf\apollo_00\src\sleep;..\..\..\..\..\..\plf\apollo_00\src\jmp_table;..\..\..\..\..\..\plf\apollo_00\src\patch_list;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\iic;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\adc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\pwm;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\timer;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\uart;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\dmac;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\qspi;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\hwecc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\rtc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\cache;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\spi;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\gpio;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\flash;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\wdt;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\periph_mngt;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\swint;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\clk_gate;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\modem;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\patch;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\pshare;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\rc_calib;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\rst_gen;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\sysctrl;..\..\..\..\..\..\plf\apollo_00\src\svcall;..\..\..\..\..\..\plf\apollo_00\src\build\ble-full\reg\fw;..\..\..\..\..\..\plf\apollo_00\src\inc;..\..\..\..\..\..\modules\rwip\api;..\..\..\..\..\..\modules\nvds\api;..\..\..\..\..\..\modules\rf\api;..\..\..\..\..\..\modules\ecc_p256\api;..\..\..\..\..\..\modules\bxfs;..\..\..\..\..\..\modules\static_buffer;..\..\..\..\..\..\ip\ble\profiles\anp\anpc\api;..\..\..\..\..\..\ip\ble\profiles\anp\anps\api;..\..\..\..\..\..\ip\ble\profiles\anp;..\..\..\..\..\..\ip\ble\profiles\bas\basc\api;..\..\..\..\..\..\ip\ble\profiles\bas\bass\api;..\..\..\..\..\..\ip\ble\profiles\bas;..\..\..\..\..\..\ip\ble\profiles\blp\blpc\api;..\..\..\..\..\..\ip\ble\profiles\blp\blps\api;..\..\..\..\..\..\ip\ble\profiles\blp;..\..\..\..\..\..\ip\ble\profiles\cpp\cppc\api;..\..\..\..\..\..\ip\ble\profiles\cpp\cpps\api;..\..\..\..\..\..\ip\ble\profiles\cpp;..\..\..\..\..\..\ip\ble\profiles\cscp\cscpc\api;..\..\..\..\..\..\ip\ble\profiles\cscp\cscps\api;..\..\..\..\..\..\ip\ble\profiles\cscp;..\..\..\..\..\..\ip\ble\profiles\dis\disc\api;..\..\..\..\..\..\ip\ble\profiles\dis\diss\api;..\..\..\..\..\..\ip\ble\profiles\dis;..\..\..\..\..\..\ip\ble\profiles\find\findl\api;..\..\..\..\..\..\ip\ble\profiles\find\findt\api;..\..\..\..\..\..\ip\ble\profiles\find;..\..\..\..\..\..\ip\ble\profiles\glp\glpc\api;..\..\..\..\..\..\ip\ble\profiles\glp\glps\api;..\..\..\..\..\..\ip\ble\profiles\glp;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpbh\api;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpd\api;..\..\..\..\..\..\ip\ble\profiles\hogp\hogprh\api;..\..\..\..\..\..\ip\ble\profiles\hogp;..\..\..\..\..\..\ip\ble\profiles\hrp\hrpc\api;..\..\..\..\..\..\ip\ble\profiles\hrp\hrps\api;..\..\..\..\..\..\ip\ble\profiles\hrp;..\..\..\..\..\..\ip\ble\profiles\htp\htpc\api;..\..\..\..\..\..\ip\ble\profiles\htp\htpt\api;..\..\..\..\..\..\ip\ble\profiles\htp;..\..\..\..\..\..\ip\ble\profiles\lan\lanc\api;..\..\..\..\..\..\ip\ble\profiles\lan\lans\api;..\..\..\..\..\..\ip\ble\profiles\lan;..\..\..\..\..\..\ip\ble\profiles\pasp\paspc\api;..\..\..\..\..\..\ip\ble\profiles\pasp\pasps\api;..\..\..\..\..\..\ip\ble\profiles\pasp;..\..\..\..\..\..\ip\ble\profiles\prox\proxm\api;..\..\..\..\..\..\ip\ble\profiles\prox\proxr\api;..\..\..\..\..\..\ip\ble\profiles\prox;..\..\..\..\..\..\ip\ble\profiles\rscp\rscpc\api;..\..\..\..\..\..\ip\ble\profiles\rscp\rscps\api;..\..\..\..\..\..\ip\ble\profiles\rscp;..\..\..\..\..\..\ip\ble\profiles\scpp\scppc\api;..\..\..\..\..\..\ip\ble\profiles\scpp\scpps\api;..\..\..\..\..\..\ip\ble\profiles\scpp;..\..\..\..\..\..\ip\ble\profiles\tip\tipc\api;..\..\..\..\..\..\ip\ble\profiles\tip\tips\api;..\..\..\..\..\..\ip\ble\profiles\tip;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotas\api;..\..\..\..\..\..\ip\ble\profiles\bxota;..\..\..\..\..\..\ip\ble\profiles\anc\ancc\api;..\..\..\..\..\..\ip\ble\profiles\anc;..\..\..\..\..\..\ip\ble\profiles\cts\ctsc\api;..\..\..\..\..\..\ip\ble\profiles\cts;..\..\..\..\..\..\ip\ble\profiles\gatts\gattsc\api;..\..\..\..\..\..\ip\ble\profiles\gatts;..\..\..\..\..\..\ip;..\..\..\..\..\..\plf\inc;..\..\..\..\..\..\plf\inc\cmsis;..\..\..\..\..\..\plf\bx_debug;..\..\..\..\..\..\plf\bx_debug\log;..\..\..\..\..\..\plf\bx_debug\log\RTT;..\..\..\..\..\..\plf\bx_debug\internal_log;..\..\..\..\..\..\plf\peripheral\app_uart;..\..\..\..\..\..\plf\peripheral\app_hwecc;..\..\..\..\..\..\plf\peripheral\led;..\..\..\..\..\..\plf\peripheral\flash;..\..\..\..\..\..\plf\peripheral\flash_cache;..\..\..\..\..\..\plf\peripheral\ssi\app_qspi;..\..\..\..\..\..\plf\peripheral\ssi\app_spi;..\..\..\..\..\..\plf\peripheral\ssi;..\..\..\..\..\..\plf\peripheral\rtc;..\..\..\..\..\..\plf\peripheral\app_dmac;..\..\..\..\..\..\plf\peripheral\sleep_recovery;..\..\..\..\..\..\plf\peripheral\app_iic;..\..\..\..\..\..\plf\peripheral\app_adc;..\..\..\..\..\..\plf\peripheral\app_timer;..\..\..\..\..\..\plf\peripheral\app_pwm;..\..\..\..\..\..\plf\peripheral\app_gpio;..\..\..\..\..\..\plf\peripheral\app_wdt;..\..\..\..\..\..\plf\peripheral\test;..\..\..\..\..\..\plf\peripheral;..\..\..\..\..\..\plf\apollo_00;..\..\..\..\..\..\plf;..\..\..\..\..\..\modules\ke\api;..\..\..\..\..\..\modules\dbg\api;..\..\..\..\..\..\modules\common\api;..\..\..\..\..\..\modules\h4tl\api;..\..\..\..\..\..\ip\ble\ll\src\llm;..\..\..\..\..\..\ip\ble\ll\src\llc;..\..\..\..\..\..\ip\ble\ll\src\lld;..\..\..\..\..\..\ip\ble\ll\src\em;..\..\..\..\..\..\ip\ble\ll\src\rwble;..\..\..\..\..\..\ip\ble\hl\api;..\..\..\..\..\..\ip\ble\hl\inc;..\..\..\..\..\..\ip\ble\hl\src\gap\gapm;..\..\..\..\..\..\ip\hci\api;..\..\..\..\..\..\ip\ahi\api;..\..\..\..\..\..\ip\ea\api;..\..\..\..\..\..\ip\em\api
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
  scatter file: ..\..\..\..\..\..\plf\apollo_00\config\linker_script\armcc\fw_usr.txt
  link misc: --diag_suppress=L6314,L6329
..\..\..\..\..\..\plf\apollo_00\config\rom_syms_armcc.txt --datacompressor=off
  group Application
    ../: simple_ctl_anl_s.c node_setup.c mesh_app_hal.c mesh_user_main.c
  group Config
    ../: sdk_mesh_config.h sdk_mesh_config_pro.h bx_app_config.h
    ../../../../: FreeRTOSConfig.h
    ../../../../../../plf/apollo_00/: bx_sys_config.h bx_pcb_config.h
    ../../../../../../ip/: bx_ip_config.h
    ../../../../../../plf/: bx_config.h
    ../../../../../../tools/image_tool_v2/: config.ini
  group Device_manager
    ../../../device_manager/api/: device_manager_api.c
    ../../../device_manager/keys/: app_keys_dm.c device_keys_dm.c network_keys_dm.c
    ../../../device_manager/node_save/: node_save.c node_save_common.c node_save_keys.c node_save_misc.c node_save_model.c node_save_scene.c node_save_scheduler.c node_save_onpowerup.c node_save_onoffcount.c
  group Core
    ../../../core/: beacon.c mesh_env.c mesh_iv_operation.c mesh_kr_comm.c mesh_kr_server.c osapp_mesh.c security.c virt_addr_mngt.c mesh_stack_init.c access_pdu_decrypt.c access_pdu_encrpyt.c access_rx_process.c access_tx_process.c adv_bearer_tx.c adv_mesh_msg_cache.c aes_128.c aes_ccm_cmac.c appkey_devkey_decrypt.c cache_management.c candidate.c model_rx.c network_msg_cache.c network_pdu_decrypt.c network_pdu_encrypt.c network_rx_process.c network_tx_process.c obfuscation.c reassembly.c adv_bearer_rx.c control_rx_process.c control_tx_process.c lower_rx_process.c lower_tx_process.c upper_rx_process.c upper_tx_process.c beacon_mesh_msg_cache.c mesh_reset_database.c k2_derivation.c friend.c low_power.c friendship.c heartbeat.c
    ../../../core/api/: mesh_core_api.c
    ../../../core/core_config/: mesh_node_base.c mesh_node_config.c beacon_config.c mesh_kr_client.c
  group Gatt
    ../../../gatt/: mesh_gatt_cfg.c mesh_gatt.c mesh_gatt_filter.c mesh_gatt_proxy.c mesh_gatt_serv_adv.c
    ../../../gatt/proxy/server/: proxy_s.c
    ../../../gatt/provisioning/server/: provisioning_s.c
  group Provision
    ../../../provision/: provision_security.c provision_comm.c provision_fsm_comm.c unprov_device_fsm.c unprov_device_intf.c provision.c provisioner_fsm.c provisioner_intf.c advertising_interfaces.c unprov_adv_interfaces.c provision_service_adv_interfaces.c
    ../../../provision/api/: provision_api.c
  group Model
    ../../../model/: mesh_model.c model_common.c model_status_switch.c model_msg.c
    ../../../model/generics/: generic_common.c
    ../../../model/generics/generic_onoff/client/: generic_onoff_client.c
    ../../../model/generics/generic_onoff/server/: generic_onoff_server.c
    ../../../model/generics/generic_onoff/: generic_onoff_msg_handler.c
    ../../../model/generics/generic_level/server/: generic_level_server.c
    ../../../model/generics/generic_level/client/: generic_level_client.c
    ../../../model/generics/generic_level/: generic_level_msg_handler.c
    ../../../model/generics/generic_transition/client/: generic_transition_client.c
    ../../../model/generics/generic_transition/server/: generic_transition_server.c
    ../../../model/generics/generic_transition/: generic_transition_msg_handler.c
    ../../../model/generics/generic_power_onoff/client/: generic_power_onoff_client.c
    ../../../model/generics/generic_power_onoff/server/: generic_power_onoff_server.c
    ../../../model/generics/generic_power_onoff/: generic_power_onoff_msg_handler.c
    ../../../model/foundation_models/: model_publish.c foundation_common.c foundation_msg_handler.c
    ../../../model/foundation_models/config/server/: config_server.c config_server_feature.c config_server_heartbeat.c config_server_key.c config_server_misc.c config_server_pub_sub.c
    ../../../model/foundation_models/health/server/: health_server.c
    ../../../model/foundation_models/health/client/: health_client.c
    ../../../model/custom_models/tmall/server/: tmall_model_server.c
    ../../../model/custom_models/tmall/client/: tmall_model_client.c
    ../../../model/custom_models/tmall/: tmall_model_msg_handler.c
    ../../../model/light_mode/light_ctl/server/: light_ctl_server.c light_ctl_temperature_server.c light_ctl_setup_server.c
    ../../../model/light_mode/light_ctl/client/: light_ctl_client.c
    ../../../model/light_mode/light_ctl/: light_ctl_msg_handler.c
    ../../../model/light_mode/light_hsl/server/: light_hsl_server.c light_hsl_hue_server.c light_hsl_saturation_server.c light_hsl_setup_server.c
    ../../../model/light_mode/light_hsl/client/: light_hsl_client.c
    ../../../model/light_mode/light_hsl/: light_hsl_msg_handler.c
    ../../../model/light_mode/light_lightness/server/: light_lightness_server.c light_lightness_setup_server.c
    ../../../model/light_mode/light_lightness/client/: light_lightness_client.c
    ../../../model/light_mode/light_lightness/: light_lightness_msg_handler.c
    ../../../model/time_and_scenes/time/server/: time_server.c
    ../../../model/time_and_scenes/time/client/: time_client.c
    ../../../model/time_and_scenes/time/: time_msg_handler.c
    ../../../model/time_and_scenes/scene/server/: scene_server.c
    ../../../model/time_and_scenes/scene/client/: scene_client.c
    ../../../model/time_and_scenes/scheduler/server/: scheduler_server.c
    ../../../model/time_and_scenes/scheduler/client/: scheduler_client.c
  group Tools
    ../../../adapter/: mesh_queued_msg.c mesh_sched.c timer_wrapper.c os_wrapper.c mesh_ble_time.c
    ../../../unit_test/security_test/: aes_ccm_test.c
    ../../../mesh_test/: mesh_iv_update_test.c mesh_kr_test.c mesh_ttl_test.c
  group Freertos
    ../../../../src/portable/ARMCC/arm_cm0/: port.c
    ../../../../src/: tasks.c queue.c list.c timers.c event_groups.c croutine.c stream_buffer.c
    ../../../../src/portable/memmang/: heap_4.c
  group Integration
    ../../../../../../plf/apollo_00/src/peripheral_integration/iic/: iic_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/adc/: adc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/pwm/: pwm_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/timer/: timer_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/uart/: uart_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/dmac/: dmac_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/qspi/: qspi_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/hwecc/: hwecc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/rtc/: rtc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/cache/: cache_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/spi/: spi_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/gpio/: gpio_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/flash/: flash_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/wdt/: wdt_integration.c
    ../../../../../../plf/apollo_00/src/sys_integration/periph_mngt/: periph_mngt.c
    ../../../../../../plf/apollo_00/src/sys_integration/swint/: swint.c
    ../../../../../../plf/apollo_00/src/sys_integration/clk_gate/: clk_gate.c
    ../../../../../../plf/apollo_00/src/sys_integration/modem/: modem.c
    ../../../../../../plf/apollo_00/src/sys_integration/patch/: patch.c
    ../../../../../../plf/apollo_00/src/sys_integration/pshare/: pshare.c
    ../../../../../../plf/apollo_00/src/sys_integration/rc_calib/: rc_calib.c true_random.c
    ../../../../../../plf/apollo_00/src/sys_integration/rst_gen/: rst_gen.c
    ../../../../../../plf/apollo_00/src/sys_integration/sysctrl/: sysctrl.c rf_reg_settings_apollo_00.c refresh_rf_param_with_ro.c io_ctrl.c touch.c
    ../../../../../../plf/apollo_00/src/patch_list/: rf_temp_adjust.c
  group Peripheral
    ../../../../../../plf/peripheral/app_uart/: app_uart.c
    ../../../../../../plf/peripheral/app_hwecc/: app_hwecc.c app_hwecc_wrapper.c
    ../../../../../../plf/peripheral/flash_cache/: flash_cache.c
    ../../../../../../plf/peripheral/ssi/app_qspi/: app_qspi.c app_qspi_wrapper.c
    ../../../../../../plf/peripheral/ssi/app_spi/: app_spi.c
    ../../../../../../plf/peripheral/app_dmac/: app_dmac.c app_dmac_wrapper.c
    ../../../../../../plf/peripheral/sleep_recovery/: periph_recovery.c
    ../../../../../../plf/peripheral/app_iic/: app_iic.c
    ../../../../../../plf/peripheral/app_adc/: app_adc.c app_adc_utils.c
    ../../../../../../plf/peripheral/app_timer/: app_timer.c
    ../../../../../../plf/peripheral/app_pwm/: app_pwm.c
    ../../../../../../plf/peripheral/app_gpio/: app_gpio.c
    ../../../../../../plf/peripheral/app_wdt/: app_wdt.c
    ../../../../../../plf/peripheral/test/: app_iic_test.c app_adc_test.c app_timer_test.c app_pwm_test.c app_gpio_test.c spi_test.c
    ../../../../../../plf/peripheral/: periph_lock.c
    ../../../../../../plf/peripheral/flash/: flash_base.c flash_wrapper.c
  group System
    ../../../../utils/bond/: bond_manage.c bond_save.c bond_save_db_cccd.c bond_save_flash.c bond_save_security.c
    ../../../../utils/: task_init.c os_bridge.c osapp_task.c ble_task.c osapp_utils.c osapp_svc_manager.c osapp_calendar.c
    ../../../../: main.c
    ../../../../../../plf/apollo_00/src/arch/: arch_init.c
    ../../../../../../plf/apollo_00/src/arch/boot/ARMCC/: startup_apollo_00.s
    ../../../../../../plf/apollo_00/src/sleep/: sys_sleep.c sys_sleep_ram.c
    ../../../../../../plf/apollo_00/src/svcall/: svcall.c
    ../../../../../../plf/apollo_00/src/svcall/ARMCC/: svcall_asm.s
    ../../../../../../ip/ble/ll/src/lld/: bx_lld_sleep.c
    ../../../../../../ip/ble/ll/src/rwble/: bx_rwble.c
    ../../../../../../ip/ble/hl/src/prf/: prf.c prf_utils.c
    ../../../../../../ip/ble/profiles/anp/anpc/src/: anpc.c anpc_task.c
    ../../../../../../ip/ble/profiles/anp/anps/src/: anps.c anps_task.c
    ../../../../../../ip/ble/profiles/bas/basc/src/: basc.c basc_task.c
    ../../../../../../ip/ble/profiles/bas/bass/src/: bass.c bass_task.c
    ../../../../../../ip/ble/profiles/blp/blpc/src/: blpc.c blpc_task.c
    ../../../../../../ip/ble/profiles/blp/blps/src/: blps.c blps_task.c
    ../../../../../../ip/ble/profiles/cpp/cppc/src/: cppc.c cppc_task.c
    ../../../../../../ip/ble/profiles/cpp/cpps/src/: cpps.c cpps_task.c
    ../../../../../../ip/ble/profiles/cscp/cscpc/src/: cscpc.c cscpc_task.c
    ../../../../../../ip/ble/profiles/cscp/cscps/src/: cscps.c cscps_task.c
    ../../../../../../ip/ble/profiles/dis/disc/src/: disc.c disc_task.c
    ../../../../../../ip/ble/profiles/dis/diss/src/: diss.c diss_task.c
    ../../../../../../ip/ble/profiles/find/findl/src/: findl.c findl_task.c
    ../../../../../../ip/ble/profiles/find/findt/src/: findt.c findt_task.c
    ../../../../../../ip/ble/profiles/glp/glpc/src/: glpc.c glpc_task.c
    ../../../../../../ip/ble/profiles/glp/glps/src/: glps.c glps_task.c
    ../../../../../../ip/ble/profiles/hogp/hogpbh/src/: hogpbh.c hogpbh_task.c
    ../../../../../../ip/ble/profiles/hogp/hogpd/src/: hogpd.c hogpd_task.c
    ../../../../../../ip/ble/profiles/hogp/hogprh/src/: hogprh.c hogprh_task.c
    ../../../../../../ip/ble/profiles/hrp/hrpc/src/: hrpc.c hrpc_task.c
    ../../../../../../ip/ble/profiles/hrp/hrps/src/: hrps.c hrps_task.c
    ../../../../../../ip/ble/profiles/htp/htpc/src/: htpc.c htpc_task.c
    ../../../../../../ip/ble/profiles/htp/htpt/src/: htpt.c htpt_task.c
    ../../../../../../ip/ble/profiles/lan/lanc/src/: lanc.c lanc_task.c
    ../../../../../../ip/ble/profiles/lan/lans/src/: lans.c lans_task.c
    ../../../../../../ip/ble/profiles/pasp/paspc/src/: paspc.c paspc_task.c
    ../../../../../../ip/ble/profiles/pasp/pasps/src/: pasps.c pasps_task.c
    ../../../../../../ip/ble/profiles/prox/proxm/src/: proxm.c proxm_task.c
    ../../../../../../ip/ble/profiles/prox/proxr/src/: proxr.c proxr_task.c
    ../../../../../../ip/ble/profiles/rscp/rscpc/src/: rscpc.c rscpc_task.c
    ../../../../../../ip/ble/profiles/rscp/rscps/src/: rscps.c rscps_task.c
    ../../../../../../ip/ble/profiles/scpp/scppc/src/: scppc.c scppc_task.c
    ../../../../../../ip/ble/profiles/scpp/scpps/src/: scpps.c scpps_task.c
    ../../../../../../ip/ble/profiles/tip/tipc/src/: tipc.c tipc_task.c
    ../../../../../../ip/ble/profiles/tip/tips/src/: tips.c tips_task.c
    ../../../../../../ip/ble/profiles/bxota/bxotas/src/: bxotas.c bxotas_task.c
    ../../../../../../ip/ble/profiles/anc/ancc/src/: ancc.c ancc_task.c
    ../../../../../../ip/ble/profiles/cts/ctsc/src/: ctsc.c ctsc_task.c
    ../../../../../../ip/ble/profiles/gatts/gattsc/src/: gattsc.c gattsc_task.c
    ../../../../../../modules/rwip/src/: rwip.c
    ../../../../../../modules/common/src/: bx_ring_queue.c queued_async_framework.c
    ../../../../../../modules/nvds/src/: nvds_in_ram.c nvds_task.c
    ../../../../../../modules/rf/src/: rf_apollo.c
    ../../../../../../modules/ecc_p256/src/: ecc_p256.c
    ../../../../../../modules/bxfs/: bxfs.c bxfs_test.c bxfs_write_cache.c
    ../../../../../../modules/static_buffer/: static_buffer.c
    ../../../../../../plf/apollo_00/src/jmp_table/: jump_table.c
    ../../../../../../plf/apollo_00/src/patch_list/: tx_test_end.c adv_int.c h4tl_patch.c set_adv_payload_31Byte_patch.c prog_latency_patch.c lld_pdu_tx_flush_list_patch.c llm_end_evt_defer_patch.c h4tl_read_start_skip_patch.c task_id_patch.c rc32k_patch.c derivation_calib_switch.c lld_slave_instant_patch.c slave_finetimecnt_patch.c smpc_construct_id_addr_type_patch.c scan_timeout_patch.c adv_report_patch.c scan_adv_rx_threshold_patch.c lld_scan_stop.c lld_evt_schedule_patch.c slave_latency_patch.c
    ../../../../../../plf/apollo_00/src/patch_list/ARMCC/: h4tl_patch_asm.s h4tl_read_start_patch_asm.s task_id_patch_asm.s lld_pdu_tx_flush_list_patch_asm.s rc32k_patch_asm.s lld_slave_instant_patch_asm.s slave_finetimecnt_patch_asm.s smpc_construct_id_addr_type_patch_asm.s adv_report_patch_asm.s lld_scan_stop.s
    ../../../../../../plf/bx_debug/: bx_dbg.c
    ../../../../../../plf/bx_debug/ARMCC/: bx_dbg_asm.s
    ../../../../../../plf/bx_debug/log/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../plf/bx_debug/log/: sim_log.c
    ../../../../../../plf/bx_debug/internal_log/: internal_log.c
    ../../../uart_ctrl/: uart_main.c uart_log_test.c provisioner_uart_test.c client_server_uart_test.c mesh_uart_ctrl.c uart_debug_test.c
