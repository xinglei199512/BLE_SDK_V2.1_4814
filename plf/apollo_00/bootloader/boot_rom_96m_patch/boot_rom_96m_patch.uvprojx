# Keil uVision project boot_rom_96m_patch.uvprojx, settings and files
target boot_rom_96m_patch (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: boot_rom_patch
  AfterMake: fromelf --bin --output=boot_rom_patch.bin .\Objects\%L
  AfterMake: fromelf -c -a -d -e -v -o boot_rom_patch.asm .\Objects\%L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NDEBUG HW_BX_VERSION=00
  c include: .\CMSIS;..\..\src\arch;..\..\bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\boot_ram_scatter.txt
  group Core
    ./: boot_ram.c startup_uart_download.s uart_6m_patch.c uart_6m_patch.h
