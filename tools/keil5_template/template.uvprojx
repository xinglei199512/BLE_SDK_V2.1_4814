# Keil uVision project template.uvprojx, settings and files
target BLE Mesh (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: simple_generic_onoff_server +hex
  AfterMake: ..\..\..\..\..\..\tools\image_tool_v2\dissemble.bat @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --bss_threshold=0
  c include: ..\..\simple_generic_onoff_server;..\..\..\examples;..\..\..\core;..\..\..\core\api;..\..\..\core\core_config;..\..\..\device_manager;..\..\..\device_manager\api;..\..\..\device_manager\keys;..\..\..\device_manager\node_save;..\..\..\gatt;..\..\..\gatt\api;..\..\..\gatt\provisioning;..\..\..\gatt\provisioning\server;..\..\..\gatt\provisioning\client;..\..\..\gatt\proxy;..\..\..\gatt\proxy\server;..\..\..\gatt\proxy\client;..\..\..\tools;..\..\..\tools\static_mem_manage;..\..\..\tools\uart_ctrl;..\..\..\provision;..\..\..\provision\api;..\..\..\model;..\..\..\model\api;..\..\..\model\foundation_models;..\..\..\model\generics;..\..\..\model\health;..\..\..\model\light_mode;..\..\..\model\generics\generic_onoff;..\..\..\model\generics\generic_level;..\..\..\model\generics\generic_location;..\..\..\model\generics\generic_default_transition_time;..\..\..\model\generics\generic_battery;..\..\..\model\generics\generic_onpowerup;..\..\..\model\generics\generic_power_level;..\..\..\model\light_mode\light_ctl;..\..\..\model\light_mode\light_hsl;..\..\..\model\light_mode\light_lightness;..\..\..\lib;..\..\..\..\..\freertos;..\..\..\..\src;..\..\..\..\src\include;..\..\..\..\src\portable;..\..\..\..\src\portable\ARMCC\ARM_CM0;..\..\..\..\src\portable\ARMCC\MemMang;..\..\..\..\utils;..\..\..\..\..\app;..\..\..\..\..\config;..\..\..\..\mesh;..\..\..\..\..\..\ip;..\..\..\..\..\..\ip\ahi\api;..\..\..\..\..\..\ip\ble\hl\api;..\..\..\..\..\..\ip\ble\hl\inc;..\..\..\..\..\..\ip\ble\hl\src\gap;..\..\..\..\..\..\ip\ble\hl\src\gap\gapc;..\..\..\..\..\..\ip\ble\hl\src\gap\gapm;..\..\..\..\..\..\ip\ble\hl\src\gap\smpc;..\..\..\..\..\..\ip\ble\hl\src\gap\smpm;..\..\..\..\..\..\ip\ble\hl\src\gatt;..\..\..\..\..\..\ip\ble\hl\src\gatt\attc;..\..\..\..\..\..\ip\ble\hl\src\gatt\attm;..\..\..\..\..\..\ip\ble\hl\src\gatt\atts;..\..\..\..\..\..\ip\ble\hl\src\gatt\gattc;..\..\..\..\..\..\ip\ble\hl\src\gatt\gattm;..\..\..\..\..\..\ip\ble\hl\src\l2c;..\..\..\..\..\..\ip\ble\hl\src\l2c\l2cc;..\..\..\..\..\..\ip\ble\hl\src\l2c\l2cm;..\..\..\..\..\..\ip\ble\hl\src\prf;..\..\..\..\..\..\ip\ble\hl\src\rwble_hl;..\..\..\..\..\..\ip\ea\api;..\..\..\..\..\..\ip\em\api;..\..\..\..\..\..\ip\hci\api;..\..\..\..\..\..\ip\hci\src;..\..\..\..\..\..\ip\ble\profiles\anp;..\..\..\..\..\..\ip\ble\profiles\anp\anpc\api;..\..\..\..\..\..\ip\ble\profiles\anp\anpc\src;..\..\..\..\..\..\ip\ble\profiles\anp\anps\api;..\..\..\..\..\..\ip\ble\profiles\anp\anps\src;..\..\..\..\..\..\ip\ble\profiles\bas;..\..\..\..\..\..\ip\ble\profiles\bas\basc\api;..\..\..\..\..\..\ip\ble\profiles\bas\basc\src;..\..\..\..\..\..\ip\ble\profiles\bas\bass\api;..\..\..\..\..\..\ip\ble\profiles\bas\bass\src;..\..\..\..\..\..\ip\ble\profiles\blp;..\..\..\..\..\..\ip\ble\profiles\blp\blpc\api;..\..\..\..\..\..\ip\ble\profiles\blp\blpc\src;..\..\..\..\..\..\ip\ble\profiles\blp\blps\api;..\..\..\..\..\..\ip\ble\profiles\blp\blps\src;..\..\..\..\..\..\ip\ble\profiles\bxota;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotac\api;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotac\src;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotas\api;..\..\..\..\..\..\ip\ble\profiles\bxota\bxotas\src;..\..\..\..\..\..\ip\ble\profiles\cpp;..\..\..\..\..\..\ip\ble\profiles\cpp\cppc\api;..\..\..\..\..\..\ip\ble\profiles\cpp\cppc\src;..\..\..\..\..\..\ip\ble\profiles\cpp\cpps\api;..\..\..\..\..\..\ip\ble\profiles\cpp\cpps\src;..\..\..\..\..\..\ip\ble\profiles\cscp;..\..\..\..\..\..\ip\ble\profiles\cscp\cscpc\api;..\..\..\..\..\..\ip\ble\profiles\cscp\cscpc\src;..\..\..\..\..\..\ip\ble\profiles\cscp\cscps\api;..\..\..\..\..\..\ip\ble\profiles\cscp\cscps\src;..\..\..\..\..\..\ip\ble\profiles\dis;..\..\..\..\..\..\ip\ble\profiles\dis\disc\api;..\..\..\..\..\..\ip\ble\profiles\dis\disc\src;..\..\..\..\..\..\ip\ble\profiles\dis\diss\api;..\..\..\..\..\..\ip\ble\profiles\dis\diss\src;..\..\..\..\..\..\ip\ble\profiles\find;..\..\..\..\..\..\ip\ble\profiles\find\findl\api;..\..\..\..\..\..\ip\ble\profiles\find\findl\src;..\..\..\..\..\..\ip\ble\profiles\find\findt\api;..\..\..\..\..\..\ip\ble\profiles\find\findt\src;..\..\..\..\..\..\ip\ble\profiles\glp;..\..\..\..\..\..\ip\ble\profiles\glp\glpc\api;..\..\..\..\..\..\ip\ble\profiles\glp\glpc\src;..\..\..\..\..\..\ip\ble\profiles\glp\glps\api;..\..\..\..\..\..\ip\ble\profiles\glp\glps\src;..\..\..\..\..\..\ip\ble\profiles\hrp;..\..\..\..\..\..\ip\ble\profiles\hrp\hrpc\api;..\..\..\..\..\..\ip\ble\profiles\hrp\hrpc\src;..\..\..\..\..\..\ip\ble\profiles\hrp\hrps\api;..\..\..\..\..\..\ip\ble\profiles\hrp\hrps\src;..\..\..\..\..\..\ip\ble\profiles\htp;..\..\..\..\..\..\ip\ble\profiles\htp\htpc\api;..\..\..\..\..\..\ip\ble\profiles\htp\htpc\src;..\..\..\..\..\..\ip\ble\profiles\htp\htpt\api;..\..\..\..\..\..\ip\ble\profiles\htp\htpt\src;..\..\..\..\..\..\ip\ble\profiles\lan;..\..\..\..\..\..\ip\ble\profiles\lan\lanc\api;..\..\..\..\..\..\ip\ble\profiles\lan\lanc\src;..\..\..\..\..\..\ip\ble\profiles\lan\lans\api;..\..\..\..\..\..\ip\ble\profiles\lan\lans\src;..\..\..\..\..\..\ip\ble\profiles\pasp;..\..\..\..\..\..\ip\ble\profiles\pasp\paspc\api;..\..\..\..\..\..\ip\ble\profiles\pasp\paspc\src;..\..\..\..\..\..\ip\ble\profiles\pasp\pasps\api;..\..\..\..\..\..\ip\ble\profiles\pasp\pasps\src;..\..\..\..\..\..\ip\ble\profiles\prox;..\..\..\..\..\..\ip\ble\profiles\prox\proxm\api;..\..\..\..\..\..\ip\ble\profiles\prox\proxm\src;..\..\..\..\..\..\ip\ble\profiles\prox\proxr\api;..\..\..\..\..\..\ip\ble\profiles\prox\proxr\src;..\..\..\..\..\..\ip\ble\profiles\rscp;..\..\..\..\..\..\ip\ble\profiles\rscp\rscpc\api;..\..\..\..\..\..\ip\ble\profiles\rscp\rscpc\src;..\..\..\..\..\..\ip\ble\profiles\rscp\rscps\api;..\..\..\..\..\..\ip\ble\profiles\rscp\rscps\src;..\..\..\..\..\..\ip\ble\profiles\scpp;..\..\..\..\..\..\ip\ble\profiles\scpp\scppc\api;..\..\..\..\..\..\ip\ble\profiles\scpp\scppc\src;..\..\..\..\..\..\ip\ble\profiles\scpp\scpps\api;..\..\..\..\..\..\ip\ble\profiles\scpp\scpps\src;..\..\..\..\..\..\ip\ble\profiles\tip;..\..\..\..\..\..\ip\ble\profiles\tip\tipc\api;..\..\..\..\..\..\ip\ble\profiles\tip\tipc\src;..\..\..\..\..\..\ip\ble\profiles\tip\tips\api;..\..\..\..\..\..\ip\ble\profiles\tip\tips\src;..\..\..\..\..\..\ip\ble\profiles\hogp;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpbh\api;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpbh\src;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpd\api;..\..\..\..\..\..\ip\ble\profiles\hogp\hogpd\src;..\..\..\..\..\..\ip\ble\profiles\hogp\hogprh\api;..\..\..\..\..\..\ip\ble\profiles\hogp\hogprh\src;..\..\..\..\..\..\ip\ble\ll\src\rwble;..\..\..\..\..\..\ip\ble\ll\src\em;..\..\..\..\..\..\ip\ble\ll\src\llc;..\..\..\..\..\..\ip\ble\ll\src\lld;..\..\..\..\..\..\ip\ble\ll\src\llm;..\..\..\..\..\..\modules\common\api;..\..\..\..\..\..\modules\dbg\api;..\..\..\..\..\..\modules\display\api;..\..\..\..\..\..\modules\display\src;..\..\..\..\..\..\modules\ecc_p256\api;..\..\..\..\..\..\modules\h4tl\api;..\..\..\..\..\..\modules\ke\api;..\..\..\..\..\..\modules\ke\src;..\..\..\..\..\..\modules\nvds\api;..\..\..\..\..\..\modules\rf\api;..\..\..\..\..\..\modules\rwip\api;..\..\..\..\..\..\plf;..\..\..\..\..\..\plf\inc;..\..\..\..\..\..\plf\inc\cmsis;..\..\..\..\..\..\plf\bx_debug;..\..\..\..\..\..\plf\bx_debug\log;..\..\..\..\..\..\plf\bx_debug\log\RTT;..\..\..\..\..\..\plf\peripheral\;..\..\..\..\..\..\plf\peripheral\swint;..\..\..\..\..\..\plf\peripheral\ssi;..\..\..\..\..\..\plf\peripheral\ssi\app_qspi;..\..\..\..\..\..\plf\peripheral\ssi\app_spi;..\..\..\..\..\..\plf\peripheral\rtc;..\..\..\..\..\..\plf\peripheral\led;..\..\..\..\..\..\plf\peripheral\hw_ecc;..\..\..\..\..\..\plf\peripheral\flash;..\..\..\..\..\..\plf\peripheral\flash_cache;..\..\..\..\..\..\plf\peripheral\sleep_recovery;..\..\..\..\..\..\plf\peripheral\app_uart;..\..\..\..\..\..\plf\peripheral\app_dmac;..\..\..\..\..\..\plf\peripheral\app_hwecc;..\..\..\..\..\..\plf\peripheral\app_adc;..\..\..\..\..\..\plf\peripheral\app_gpio;..\..\..\..\..\..\plf\peripheral\app_iic;..\..\..\..\..\..\plf\peripheral\app_pwm;..\..\..\..\..\..\plf\peripheral\app_timer;..\..\..\..\..\..\plf\apollo_00;..\..\..\..\..\..\plf\apollo_00\src;..\..\..\..\..\..\plf\apollo_00\src\arch;..\..\..\..\..\..\plf\apollo_00\src\arch\boot\armcc;..\..\..\..\..\..\plf\apollo_00\src\arch\compiler\armcc;..\..\..\..\..\..\plf\apollo_00\src\arch\ll\;..\..\..\..\..\..\plf\apollo_00\src\build\ble-full\reg\fw;..\..\..\..\..\..\plf\apollo_00\src\jmp_table;..\..\..\..\..\..\plf\apollo_00\src\patch_list;..\..\..\..\..\..\plf\apollo_00\src\sleep;..\..\..\..\..\..\plf\apollo_00\src\inc;..\..\..\..\..\..\plf\apollo_00\src\arch\boot\armcc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\adc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\cache;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\charger;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\dmac;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\gpio;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\hwecc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\iic;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\pwm;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\qspi;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\rtc;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\spi;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\uart;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\timer;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\clk_gate;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\modem;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\patch;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\periph_mngt;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\pshare;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\rc_calib;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\rst_gen;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\swint;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\sysctrl;..\..\..\..\..\..\plf\bx_debug\internal_log;..\..\..\mesh_test;..\..\..\..\..\..\app;..\..\..\..\..\baremetal\api;..\..\..\..\..\baremetal\src;..\..\..\..\..\..\modules\bxfs;..\apollo_00_keil5;..\..\..\model\custom_models\custom_vendor;..\..\..\model\health;..\..\..\model\light_mode\light_ctl;..\..\..\model\light_mode\light_hsl;..\..\..\model\light_mode\light_lightness;..\..\..\..\utils;..\..\..\model\time_and_scenes\scheduler;..\..\..\model\time_and_scenes\scene;..\..\..\model\time_and_scenes\time;..\..\..\..\..\..\plf\apollo_00\src\sys_integration\swint;..\..\..\model\health;..\..\..\model\heartbeat;..\..\..\model\health;..\..\..\model\heartbeat;..\..\..\..\..\..\plf\apollo_00\src\svcall;..\..\..\model\generics\generic_transition;..\..\..\model\time_and_scenes\scene;..\..\..\model\sensors;..\..\..\..\..\..\plf\apollo_00\src\peripheral_integration\flash;..\..\..\adapter;..\..\..\..\..\..\modules\static_buffer;..\..\..\..\..\..\plf\peripheral
  asm include: None
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x100000 size 0x30000
  scatter file: ..\..\..\..\..\..\plf\apollo_00\config\linker_script\armcc\fw_usr.txt
  link misc: --diag_suppress=L6314,L6329
..\..\..\..\..\..\plf\apollo_00\config\rom_syms_armcc.txt --datacompressor=off
  group Application
    ../: mesh_app.c mesh_app_hal.c mesh_user_main.c simple_generic_onoff_s.c
  group Config
    ../: sdk_mesh_config_pro.h sdk_mesh_config.h bx_app_config.h
    ../../../../../../plf/apollo_00/: bx_sys_config.h
    ../../../../: FreeRTOSConfig.h
    ../../../core/core_config/: stack_mem_cfg.c
    ../../../../../../modules/static_buffer/: static_buffer.c
    ../../../../../../tools/image_tool_v2/: config.ini
  group Device_manager
    ../../../device_manager/api/: device_manager_api.c
    ../../../device_manager/keys/: app_keys_dm.c device_keys_dm.c network_keys_dm.c
    ../../../device_manager/node_save/: node_save.c node_save_common.c node_save_keys.c node_save_misc.c node_save_model.c node_save_scene.c node_save_scheduler.c node_save_onoffcount.c node_save_onpowerup.c
  group Model
    ../../../model/: config_client.c config_server.c sig_msg.c mesh_model.c model_common.c model_status_switch.c
    ../../../model/generics/: generic_common.c
    ../../../model/generics/generic_onoff/: generic_onoff_client.c generic_onoff_server.c
    ../../../model/foundation_models/: config_composition_data.c config_relay.c config_server_publication.c config_server_subscription.c config_server_virt.c model_publish.c config_proxy.c
    ../../../model/generics/generic_level/: generic_level_server.c generic_level_client.c
    ../../../model/custom_models/custom_vendor/: custom_vendor_client.c custom_vendor_server.c
    ../../../model/light_mode/light_ctl/: light_ctl_client.c light_ctl_server.c light_ctl_setup_server.c light_ctl_temperature_server.c
    ../../../model/light_mode/light_hsl/: light_hsl_client.c light_hsl_hue_server.c light_hsl_saturation_server.c light_hsl_server.c light_hsl_setup_server.c
    ../../../model/light_mode/light_lightness/: light_lightness_client.c light_lightness_server.c light_lightness_setup_server.c
    ../../../model/time_and_scenes/scene/: scene_client.c scene_server.c
    ../../../model/time_and_scenes/scheduler/: scheduler_client.c scheduler_server.c
    ../../../model/time_and_scenes/time/: time_client.c time_server.c
    ../../../model/sensors/: sensor_client.c sensor_server.c sensor_server_setup.c
    ../../../model/heartbeat/: heartbeat_client.c heartbeat_server.c
    ../../../model/health/: health_client.c health_server.c
    ../../../model/generics/generic_transition/: generic_transition_client.c generic_transition_server.c
    ../../../model/generics/generic_onpowerup/: generic_onpowerup_client.c generic_onpowerup_server.c
  group Freertos
    ../../../../src/portable/MemMang/: heap_4.c
    ../../../../src/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../src/portable/ARMCC/ARM_CM0/: port.c
  group Core
    ../../../core/api/: mesh_core_api.c
    ../../../provision/api/: provision_api.c
    ../../../../../../plf/apollo_00/src/arch/boot/armcc/: startup_apollo_00.s
    ../../../../../../ip/ble/hl/src/prf/: prf.c prf_utils.c
    ../../../../../../ip/ble/ll/src/lld/: bx_lld_sleep.c
    ../../../../../../ip/ble/ll/src/rwble/: bx_rwble.c
    ../../../../../../plf/apollo_00/src/jmp_table/: jump_table.c
    ../../../../../../plf/apollo_00/src/patch_list/: patch_test.c tx_test_end.c patch_list.s adv_int.c h4tl_patch.c prog_latency_patch.c set_adv_payload_31Byte_patch.c h4tl_read_start_skip_patch.c llm_end_evt_defer_patch.c lld_pdu_tx_flush_list_patch.c lld_slave_instant_patch.c rc32k_patch.c scan_timeout_patch.c slave_finetimecnt_patch.c smpc_construct_id_addr_type_patch.c lld_evt_schedule_patch.c lld_scan_stop.c adv_report_patch.c scan_adv_rx_threshold_patch.c
    ../../../../../../plf/apollo_00/src/sleep/: sys_sleep.c sys_sleep_ram.c
    ../../../../../../plf/apollo_00/src/patch_list/armcc/: h4tl_read_start_patch_asm.s h4tl_patch_asm.s lld_pdu_tx_flush_list_patch_asm.s lld_slave_instant_patch_asm.s rc32k_patch_asm.s slave_finetimecnt_patch_asm.s smpc_construct_id_addr_type_patch_asm.s adv_report_patch_asm.s lld_scan_stop.s
    ../../../../utils/: ble_task.c os_bridge.c osapp_task.c osapp_utils.c task_init.c
    ../../../core/core_config/: beacon_config.c mesh_kr_client.c mesh_node_base.c mesh_node_config.c
    ../../../../../../plf/apollo_00/src/arch/: arch_init.c
    ../../../../: main.c
    ../../../../../../plf/apollo_00/src/svcall/: svcall.c
    ../../../../../../ip/ble/profiles/bxota/bxotas/src/: bxotas_task.c bxotas.c
    ../../../core/: access_api.c access_pdu_decrypt.c access_pdu_encrpyt.c access_rx_process.c access_tx_process.c adv_bearer_rx.c adv_bearer_tx.c adv_mesh_msg_cache.c aes_128.c aes_ccm_cmac.c appkey_devkey_decrypt.c beacon.c beacon_mesh_msg_cache.c cache_management.c candidate.c control_rx_process.c control_tx_process.c incomplete_rx_process.c lower_rx_process.c lower_tx_process.c mesh_env.c mesh_iv_operation.c mesh_kr_comm.c mesh_kr_server.c mesh_reset_database.c mesh_stack_init.c model_rx.c model_tx.c network_msg_cache.c network_pdu_decrypt.c network_pdu_encrypt.c network_rx_process.c network_tx_process.c obfuscation.c osapp_mesh.c reassembly.c replay_protect.c sdk_mesh_definitions.c security.c upper_rx_process.c upper_tx_process.c virt_addr_mngt.c friend.c friendship.c low_power.c k2_derivation.c
    ../../../adapter/: mesh_ble_time.c
  group Gatt
    ../../../gatt/: mesh_gatt.c mesh_gatt_cfg.c mesh_gatt_filter.c mesh_gatt_proxy.c mesh_gatt_serv_adv.c
    ../../../gatt/provisioning/server/: provisioning_s.c
    ../../../gatt/proxy/server/: proxy_s.c
  group Integration
    ../../../../../../plf/apollo_00/src/sys_integration/clk_gate/: clk_gate.c
    ../../../../../../plf/apollo_00/src/sys_integration/modem/: modem.c
    ../../../../../../plf/apollo_00/src/sys_integration/patch/: patch.c
    ../../../../../../plf/apollo_00/src/sys_integration/periph_mngt/: periph_mngt.c
    ../../../../../../plf/apollo_00/src/sys_integration/pshare/: pshare.c
    ../../../../../../plf/apollo_00/src/sys_integration/rc_calib/: rc_calib.c
    ../../../../../../plf/apollo_00/src/sys_integration/rst_gen/: rst_gen.c
    ../../../../../../plf/apollo_00/src/sys_integration/sysctrl/: io_ctrl.c rf_reg_settings_apollo_00.c sysctrl.c touch.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/adc/: adc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/cache/: cache_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/dmac/: dmac_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/gpio/: gpio_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/hwecc/: hwecc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/iic/: iic_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/pwm/: pwm_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/qspi/: qspi_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/rtc/: rtc_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/spi/: spi_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/timer/: timer_integration.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/uart/: uart_integration.c
    ../../../../../../plf/apollo_00/src/svcall/armcc/: svcall_asm.s
  group Peripheral
    ../../../../../../plf/peripheral/app_adc/: app_adc.c
    ../../../../../../plf/peripheral/app_dmac/: app_dmac.c app_dmac_wrapper.c
    ../../../../../../plf/peripheral/app_gpio/: app_gpio.c
    ../../../../../../plf/peripheral/app_hwecc/: app_hwecc.c app_hwecc_wrapper.c
    ../../../../../../plf/peripheral/app_iic/: app_iic.c
    ../../../../../../plf/peripheral/app_pwm/: app_pwm.c
    ../../../../../../plf/peripheral/app_timer/: app_timer.c
    ../../../../../../plf/peripheral/app_uart/: app_uart.c
    ../../../../../../plf/peripheral/flash_cache/: flash_cache.c
    ../../../../../../plf/peripheral/sleep_recovery/: periph_recovery.c
    ../../../../../../plf/peripheral/ssi/app_qspi/: app_qspi.c app_qspi_wrapper.c
    ../../../../../../plf/peripheral/ssi/app_spi/: app_spi.c
    ../../../../../../plf/apollo_00/src/peripheral_integration/flash/: flash_integration.c
    ../../../../../../plf/apollo_00/src/sys_integration/swint/: swint.c
    ../../../../../../plf/peripheral/flash/: flash_base.c flash_wrapper.c
    ../../../../../../plf/peripheral/: periph_lock.c
    ../../../../../../modules/bxfs/: bxfs_write_cache.c
  group Tools
    ../../../tools/: mesh_tools.c
    ../../../../../../modules/bxfs/: bxfs.c
    ../../../../../../plf/bx_debug/internal_log/: internal_log.c
    ../../../../../../modules/dbg/src/: dbg.c dbg_mwsgen.c dbg_swdiag.c dbg_task.c
    ../../../../../../modules/display/src/: display.c display_task.c
    ../../../../../../modules/ecc_p256/src/: ecc_p256.c
    ../../../../../../modules/nvds/src/: nvds_in_ram.c
    ../../../../../../modules/rf/src/: rf_apollo.c
    ../../../../../../modules/rwip/src/: rwip.c
    ../../../../../../modules/common/src/: bx_ring_queue.c queued_async_framework.c
    ../../../../../../plf/bx_debug/log/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../../plf/bx_debug/log/: sim_log.c
    ../../../../../../plf/bx_debug/armcc/: bx_dbg_asm.s
    ../../../../../../plf/bx_debug/: bx_dbg.c
    ../../../tools/uart_ctrl/: client_server_uart_test.c mesh_uart_ctrl.c provisioner_uart_test.c uart_debug_test.c uart_log_test.c uart_main.c
    ../../../../utils/: osapp_calendar.c osapp_svc_manager.c
    ../../../adapter/: mesh_queued_msg.c mesh_sched.c os_wrapper.c timer_wrapper.c
    ../../../../../../plf/apollo_00/src/sys_integration/rc_calib/: true_random.c
  group provision
    ../../../provision/: provision.c provision_comm.c provision_fsm_comm.c provision_security.c provisioner_fsm.c provisioner_intf.c unprov_device_fsm.c unprov_device_intf.c
